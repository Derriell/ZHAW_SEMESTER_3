# Keil uVision project project-1.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: CT_Board_HS14_M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.4
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project-1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group Source Group 1
    ./app/: main.c utils_ctboard.c cdBoardAdresses.h utils_ctboard.h displayPattern.h
software components: Device:Startup 4.0.4, HAL:FMC 4.0.4, HAL:GPIO 4.0.4, HAL:PWR 4.0.4, HAL:RCC 4.0.4
